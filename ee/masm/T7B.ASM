PUBLIC ZC ;zc公用
PUBLIC ZX ;zx公用
EXTRN TISHI1:BYTE 
EXTRN TISHI2:BYTE
EXTRN DA:BYTE
DATA SEGMENT COMMON 
DB 5 DUP(?) 
DATA ENDS 

CODE SEGMENT PUBLIC 
ASSUME CS:CODE,DS:DATA 
ZC PROC ;输出提示1
    MOV AH,9 
    MOV DX,OFFSET TISHI1 
    INT 21H 
    RET 
ZC ENDP
ZX PROC      
    LEA DI,DA 
    ADD DI,3 ;DA第四位
    MOV BX,16 
GOON: MOV DX,0 
    DIV BX ;从4到1
    MOV [DI],DL 
    DEC DI 
    CMP AX,0 
    LEA SI,DA      
    JZ CON 
    JMP GOON
CON:MOV CX,0004 
CONTINUE:MOV AL,[SI] 
    CMP AL,10 
    JB  A 
    ADD AL,37H ;A~F显示
    MOV [SI],AL 
    INC SI 
    JMP NEX 
A:  ADD AL,30H 
    MOV[SI],AL 
    INC SI 
NEX: LOOP CONTINUE ;循环4次
    MOV AH,9 
    MOV DX,OFFSET TISHI2 
    INT 21H  
    LEA SI,DA 
    MOV AH,2 
    MOV CX,0004 
SHUCHU:  MOV DL,[SI] ;输出结果
    INT 21H 
    INC SI 
    LOOP SHUCHU 
    RET 
ZX ENDP 
CODE ENDS 
END 